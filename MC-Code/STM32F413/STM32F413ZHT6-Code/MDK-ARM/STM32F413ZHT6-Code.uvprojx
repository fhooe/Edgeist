# Keil uVision project STM32F413ZHT6-Code.uvprojx, settings and files
target STM32F413ZHT6-Code (6190000::V6.19::ARMCLANG)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F413ZHT6-Code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F413xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\W5500\Ethernet\inc;..\..\..\W5500\Communication\inc
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group w5500
    ../../../W5500/Ethernet/inc/: socket.h w5500.h w5500_spi.h wizchip_conf.h
    ../../../W5500/Ethernet/src/: socket.c w5500.c w5500_spi.c wizchip_conf.c
  group stm32f413
    ../Core/Inc/: spi1_cs.h
    ../Core/Src/: spi1_cs.c
  group Socket_Generation
    ../../../W5500/Communication/inc/: Socket_setup.h
    ../../../W5500/Communication/src/: Socket_setup.c
software components: CMSIS:CORE 5.6.0
