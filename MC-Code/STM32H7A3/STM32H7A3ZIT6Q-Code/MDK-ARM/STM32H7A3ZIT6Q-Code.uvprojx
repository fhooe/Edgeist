# Keil uVision project STM32H7A3ZIT6Q-Code.uvprojx, settings and files
target STM32H7A3ZIT6Q-Code (6190000::V6.19::ARMCLANG)
  device: STM32H7A3ZITxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x240FFFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7A3ZIT6Q-Code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_DIRECT_SMPS_SUPPLY,USE_HAL_DRIVER,STM32H7A3xxQ,_WIZCHIP_=5500
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../../../W5500/Ethernet/inc;../../../W5500/Communication/inc;..\ProjectSpecific\Inc;..\ProjectSpecific\Assambler
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: ..\ProjectSpecific\STM32H7A3ZIT6Q-Code.sct
  group Application/MDK-ARM
    ./: startup_stm32h7a3xxq.s
    ./: STM32H7A3ZIT6Q.axf
  group Application/User/Core
    ../Core/Src/: gpio.c memorymap.c spi.c stm32h7xx_it.c stm32h7xx_hal_msp.c main.cpp
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group w5500
    ../../../W5500/Ethernet/inc/: socket.h w5500.h w5500_spi.h wizchip_conf.h
    ../../../W5500/Ethernet/src/: w5500.c socket.c w5500_spi.c wizchip_conf.c
  group Socket-Setup
    ../../../W5500/Communication/inc/: Socket_setup.h
    ../../../W5500/Communication/src/: Socket_setup.c
  group ProjectSpecific
    ../ProjectSpecific/Inc/: flash_manager.h spi1_cs.h
    ../ProjectSpecific/Src/: flash_manager.cpp spi1_cs.c
    ../ProjectSpecific/Assambler/: model_data.s model_info.s
software components: CMSIS:CORE 5.6.0
